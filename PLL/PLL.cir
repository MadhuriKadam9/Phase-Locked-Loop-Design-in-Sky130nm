* D:\soc\PLL\PLL.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/07/22 20:43:39

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U7  vdd out3 A Net-_U1-Pad1_ Net-_U2-Pad3_ Net-_U1-Pad3_ adc_bridge_3
U14  Net-_U1-Pad4_ QA dac_bridge_1
v1  vdd GND DC
v2  A GND pulse
U16  QA plot_v1
U4  vdd plot_v1
U5  A plot_v1
U13  Net-_U13-Pad1_ Net-_U1-Pad4_ Net-_U1-Pad2_ d_and
U15  Net-_U13-Pad1_ QB dac_bridge_1
U17  QB plot_v1
U6  Net-_U1-Pad2_ Rstn dac_bridge_1
U3  Rstn plot_v1
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ dff
U2  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U2-Pad3_ Net-_U13-Pad1_ dff
X1  vdd QA QB CP Charge_Pump
U21  CP plot_v1
scmode1  SKY130mode
SC1  CP Net-_SC1-Pad2_ vdd sky130_fd_pr__res_generic_pd
SC2  Net-_SC1-Pad2_ GND sky130_fd_pr__cap_mim_m3_1
SC3  CP GND sky130_fd_pr__cap_mim_m3_1
X2  vdd CP ? Fout GND avsdvco_1v8
U22  Fout plot_v1
U20  Net-_U18-Pad3_ Net-_U18-Pad4_ Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ Net-_U12-Pad4_ freq_divideby_8nw
v3  rst GND pulse
U18  Fout rst Net-_U18-Pad3_ Net-_U18-Pad4_ adc_bridge_2
U12  Net-_U12-Pad1_ Net-_U12-Pad2_ Net-_U12-Pad3_ Net-_U12-Pad4_ out3 out2 out1 out0 dac_bridge_4
U19  rst plot_v1
U8  out3 plot_v1
U10  out2 plot_v1
U9  out0 plot_v1
U11  out1 plot_v1
U23  CP IC

.end
