* C:\FOSSEE\eSim\library\SubcircuitLibrary\Charge_Pump\Charge_Pump.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 10/04/22 00:16:46

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
SC2  Net-_SC1-Pad1_ /up GND GND sky130_fd_pr__nfet_01v8
SC1  Net-_SC1-Pad1_ /up /vdd /vdd sky130_fd_pr__pfet_01v8
SC4  Net-_SC3-Pad1_ /down GND GND sky130_fd_pr__nfet_01v8
SC3  Net-_SC3-Pad1_ /down /vdd /vdd sky130_fd_pr__pfet_01v8
SC7  Net-_SC1-Pad1_ /vdd Net-_SC13-Pad2_ Net-_SC13-Pad2_ sky130_fd_pr__pfet_01v8
SC8  Net-_SC1-Pad1_ GND Net-_SC13-Pad2_ Net-_SC13-Pad2_ sky130_fd_pr__nfet_01v8
SC5  Net-_SC3-Pad1_ /vdd Net-_SC10-Pad2_ Net-_SC10-Pad2_ sky130_fd_pr__pfet_01v8
SC6  Net-_SC3-Pad1_ GND Net-_SC10-Pad2_ Net-_SC10-Pad2_ sky130_fd_pr__nfet_01v8
SC9  Net-_SC13-Pad1_ /up Net-_SC13-Pad1_ Net-_SC13-Pad1_ sky130_fd_pr__pfet_01v8
SC11  GND GND /vdd /vdd sky130_fd_pr__pfet_01v8
SC13  Net-_SC13-Pad1_ Net-_SC13-Pad2_ /vdd /vdd sky130_fd_pr__pfet_01v8
SC14  /cp GND Net-_SC13-Pad1_ Net-_SC13-Pad1_ sky130_fd_pr__pfet_01v8
SC10  Net-_SC10-Pad1_ Net-_SC10-Pad2_ Net-_SC10-Pad1_ Net-_SC10-Pad1_ sky130_fd_pr__nfet_01v8
SC12  /vdd /vdd GND GND sky130_fd_pr__nfet_01v8
SC16  Net-_SC10-Pad1_ /down GND GND sky130_fd_pr__nfet_01v8
SC15  /cp /vdd Net-_SC10-Pad1_ Net-_SC10-Pad1_ sky130_fd_pr__nfet_01v8
scmode1  SKY130mode
U1  /vdd /up /down /cp PORT

.end
